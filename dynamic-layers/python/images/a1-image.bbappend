
IMAGE_INSTALL:append = " \
  python3 \
  python3-pip \
  python3-paramiko \
"
