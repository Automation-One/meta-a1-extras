
IMAGE_INSTALL:append = " rauc "
