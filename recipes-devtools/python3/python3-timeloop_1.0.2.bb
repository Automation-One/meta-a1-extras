SUMMARY = "This is a Python3 package for creating easy threads, which are called in fixed intervals"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

HOMEPAGE = "git://github.com/sankalpjonn/timeloop.git;protocol=https;branch=master"

SRC_URI[md5sum] = "791704da1f2e0494aa79229d999fd8cb"
SRC_URI[sha256sum] = "4e716c67fe6bcadcee7ddb91e2520792426818a70f27e630cfbbbd9becc48a13"



PYPI_PACKAGE = "timeloop"

inherit pypi setuptools3

