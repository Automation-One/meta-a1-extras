
PACKAGECONFIG:append = " gpioset-interactive tests "
